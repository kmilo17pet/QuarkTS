# IAR project Backup of c-stat-check.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\src\config; ..\src\os\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: c-stat-check.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  group include
    ../src/os/include/: qatcli.h qbsbuffers.h qclock.h qcoroutine.h qcritical.h qedgecheck.h qflm.h qfsm.h qioutils.h qkernel.h qkshared.h qlists.h qmemmang.h qqueues.h qresponse.h qstimers.h qtasks.h qtrace.h qtypes.h QuarkTS.h
    ../src/config/: qconfig.h
  group src
    ../src/os/: qatcli.c qbsbuffers.c qclock.c qcoroutine.c qcritical.c qedgecheck.c qfsm.c qioutils.c qkernel.c qlists.c qmemmang.c qqueues.c qresponse.c qstimers.c qtasks.c qtrace.c
