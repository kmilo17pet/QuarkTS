<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\c-stat-check.ewp</path>
    </project>
    <batchBuild />
</workspace>
